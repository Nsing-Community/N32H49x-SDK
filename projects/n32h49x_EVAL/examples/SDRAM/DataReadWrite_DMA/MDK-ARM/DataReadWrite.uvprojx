# Keil uVision project DataReadWrite.uvprojx, settings and files
target N32H49x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H497xG Nsingtech
  pack: Nsingtech.N32H49x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x90000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DataReadWrite +hex
  AfterMake: fromelf --bin --output=.\N32H49x\bin\DataReadWrite.bin .\N32H49x\Objects\DataReadWrite.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H49x,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h49x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x90000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h49x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h49x.c
  group FWLB
    ../../../../../../firmware/n32h49x_std_periph_driver/src/: misc.c n32h49x_rcc.c n32h49x_gpio.c n32h49x_usart.c n32h49x_sdram.c n32h49x_dma.c
  group USER
    ../src/: main.c n32h49x_it.c bsp_sdram.c
  group BSP
    ../../../../bsp/src/: log.c delay.c
  group DOC
    ../: readme.txt
