# Keil uVision project Camera.uvprojx, settings and files
target N32H49X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H497xG Nsingtech
  pack: Nsingtech.N32H49x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x90000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output=.\bin\project.bin .\Camera\project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H49X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h49x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x90000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h49x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h49x.c
  group FWLB
    ../../../../../../firmware/n32h49x_std_periph_driver/src/: misc.c n32h49x_femc.c n32h49x_gpio.c n32h49x_rcc.c n32h49x_usart.c n32h49x_dvp.c
  group USER
    ../src/: main.c n32h49x_it.c fonts.c lcd.c logo1.c logo2.c bsp_dvp.c bsp_ov5640.c dvp_demo.c
  group DOC
    ../: readme.txt
  group BSP
    ../../../../bsp/src/: log.c delay.c
