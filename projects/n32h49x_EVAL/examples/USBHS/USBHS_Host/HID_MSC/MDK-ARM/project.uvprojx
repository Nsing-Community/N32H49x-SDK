# Keil uVision project project.uvprojx, settings and files
target N32H49X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H497xG Nsingtech
  pack: Nsingtech.N32H49x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x90000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output=.\bin\project.bin .\Objects\project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H49X, USE_STDPERIPH_DRIVER,HSE_VALUE=16000000,SYSCLK_SRC=SYSCLK_USE_HSE_PLL,USE_USB_HS_IN_HS
  c include: ..\inc;..\..\..\..\..\bsp\inc;..\..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\..\firmware\n32h49x_std_periph_driver\inc;..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\driver\inc;..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\host\core\inc;..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\host\class\MSC\inc;..\..\..\..\..\..\..\middlewares\fat_fs\src;..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\host\class\HID\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x90000
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32h49x.s
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32h49x.c
  group FWLB
    ../../../../../../../firmware/n32h49x_std_periph_driver/src/: misc.c n32h49x_dbg.c n32h49x_exti.c n32h49x_flash.c n32h49x_gpio.c n32h49x_pwr.c n32h49x_rcc.c n32h49x_usart.c
  group USER
    ../src/: main.c n32h49x_it.c usb_host_user_print.c usbh_user.c usbhs_bsp.c
  group n32h49x_usbhs_host
    ../../../../../../../firmware/n32h49x_usbhs_driver/driver/src/: usbhs_core.c usbhs_hcd.c usbhs_hcd_int.c
  group usbhs_host_driver
    ../../../../../../../firmware/n32h49x_usbhs_driver/host/core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group usbhs_host_class
    ../../../../../../../firmware/n32h49x_usbhs_driver/host/class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
    ../../../../../../../firmware/n32h49x_usbhs_driver/host/class/HID/src/: usbh_hid_core.c usbh_hid_keyboard.c usbh_hid_mouse.c
  group DOC
    ../: readme.txt
  group BSP
    ../../../../../bsp/src/: log.c bsp_eval.c delay.c
  group FATFS
    ../../../../../../../middlewares/fat_fs/src/: ff.c
