# IAR project project.ewp, settings and files
configuration N32H49X (ARM, debug)
  General.OGChipSelectEditMenu: N32H497xG Nsing N32H497xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H49X; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER; HSE_VALUE=16000000; SYSCLK_SRC=SYSCLK_USE_HSE_PLL; USE_USB_HS_IN_FS
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\..\firmware\n32h49x_std_periph_driver\inc; ..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\driver\inc; ..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\device\core\inc; ..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\device\class\msc\inc; ..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\device\class\hid_msc_composite\inc; ..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\device\class\customhid\inc; ..\..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LedBlink.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../../bsp/src/: bsp_eval.c delay.c
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32h49x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../../firmware/n32h49x_std_periph_driver/src/: misc.c n32h49x_dbg.c n32h49x_dma.c n32h49x_exti.c n32h49x_flash.c n32h49x_gpio.c n32h49x_pwr.c n32h49x_rcc.c n32h49x_sdio.c n32h49x_spi.c n32h49x_usart.c
  group n32h49x_usbhs_device
    ../../../../../../../firmware/n32h49x_usbhs_driver/driver/src/: usbhs_core.c usbhs_dcd.c usbhs_dcd_int.c
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32h49x_EWARM.s
  group usbhs_device_class
    ../../../../../../../firmware/n32h49x_usbhs_driver/device/class/customhid/src/: usbd_customhid_core.c
    ../../../../../../../firmware/n32h49x_usbhs_driver/device/class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ../../../../../../../firmware/n32h49x_usbhs_driver/device/class/hid_msc_composite/src/: usbd_msc_hid_core.c
  group usbhs_device_driver
    ../../../../../../../firmware/n32h49x_usbhs_driver/device/core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USER
    ../src/: main.c n32h49x_it.c spi_flash.c usbd_desc.c usbd_storage.c usbd_user.c usbhs_bsp.c
