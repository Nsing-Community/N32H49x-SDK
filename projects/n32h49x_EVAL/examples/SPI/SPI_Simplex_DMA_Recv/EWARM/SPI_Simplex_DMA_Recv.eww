<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SPI_Simplex_DMA_Recv.ewp</path>
  </project>
  <batchBuild/>
</workspace>
