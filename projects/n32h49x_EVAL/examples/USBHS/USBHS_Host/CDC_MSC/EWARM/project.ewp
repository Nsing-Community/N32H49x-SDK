# IAR project project.ewp, settings and files
configuration N32H49X (ARM, debug)
  General.OGChipSelectEditMenu: N32H497xG Nsing N32H497xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H49X; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER; HSE_VALUE=16000000; SYSCLK_SRC=SYSCLK_USE_HSE_PLL; USE_USB_HS_IN_HS
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\..\firmware\n32h49x_std_periph_driver\inc; ..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\driver\inc; ..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\host\core\inc; ..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\host\class\MSC\inc; ..\..\..\..\..\bsp\inc; ..\..\..\..\..\..\..\middlewares\fat_fs\src; ..\..\..\..\..\..\..\firmware\n32h49x_usbhs_driver\host\class\CDC\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LedBlink.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../../bsp/src/: bsp_eval.c delay.c log.c
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32h49x.c
  group DOC
    ../: readme.txt
  group FATFS
    ../../../../../../../middlewares/fat_fs/src/: ff.c
  group FWLB
    ../../../../../../../firmware/n32h49x_std_periph_driver/src/: misc.c n32h49x_dbg.c n32h49x_exti.c n32h49x_flash.c n32h49x_gpio.c n32h49x_pwr.c n32h49x_rcc.c n32h49x_usart.c
  group n32h49x_usbhs_host
    ../../../../../../../firmware/n32h49x_usbhs_driver/driver/src/: usbhs_core.c usbhs_hcd.c usbhs_hcd_int.c
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32h49x_EWARM.s
  group usbhs_host_class
    ../../../../../../../firmware/n32h49x_usbhs_driver/host/class/CDC/src/: usbh_cdc_core.c usbh_cdc_funct.c
    ../../../../../../../firmware/n32h49x_usbhs_driver/host/class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group usbhs_host_driver
    ../../../../../../../firmware/n32h49x_usbhs_driver/host/core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USER
    ../src/: main.c n32h49x_it.c usbh_data.c usbh_fs.c usbh_user.c usbhs_bsp.c
