# IAR project PMBUS_Master_Int.ewp, settings and files
configuration N32H49X (ARM, debug)
  General.OGChipSelectEditMenu: N32H497xG Nsing N32H497xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H49X; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32h49x_std_periph_driver/inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PMBUS_Master_Int.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h49x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32h49x_std_periph_driver/src/: misc.c n32h49x_crc.c n32h49x_dma.c n32h49x_exti.c n32h49x_gpio.c n32h49x_i2c.c n32h49x_rcc.c n32h49x_spi.c n32h49x_usart.c
  group LOG
    ../../../../bsp/src/: delay.c log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h49x_EWARM.s
  group USER
    ../src/: I2CMaster.c main.c n32h49x_it.c PMBusMaster.c
