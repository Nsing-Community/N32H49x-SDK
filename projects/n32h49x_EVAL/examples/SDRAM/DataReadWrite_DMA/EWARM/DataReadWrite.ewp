# IAR project DataReadWrite.ewp, settings and files
configuration N32H49x (ARM, debug)
  General.OGChipSelectEditMenu: N32H497xG Nsing N32H497xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H49X; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\n32h49x_std_periph_driver\inc; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\bsp\inc; ..\..\..\..\..\..\firmware\CMSIS\device; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DataReadWrite.bin
  ILINK.IlinkOutputFile: DataReadWrite.out
  group BSP
    ../../../../bsp/src/: delay.c log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h49x.c
  group DOC
    ../: readme.txt
  group FWIB
    ../../../../../../firmware/n32h49x_std_periph_driver/src/: misc.c n32h49x_dma.c n32h49x_gpio.c n32h49x_rcc.c n32h49x_sdram.c n32h49x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h49x_EWARM.s
  group USER
    ../src/: bsp_sdram.c main.c n32h49x_it.c
