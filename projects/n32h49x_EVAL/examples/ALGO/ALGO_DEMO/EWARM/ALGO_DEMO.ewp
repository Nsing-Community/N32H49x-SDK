# IAR project ALGO_DEMO.ewp, settings and files
configuration N32H49X (ARM, debug)
  General.OGChipSelectEditMenu: N32H497xG Nsing N32H497xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32H49X; USE_STDPERIPH_DRIVER; _DLIB_FILE_DESCRIPTOR; __IAR_ARM
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32h49x_std_periph_driver/inc; ../../../../bsp/inc; ..\..\..\..\..\..\firmware\n32h49x_algo_lib\gcc\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\firmware\n32h49x_algo_lib\gcc\lib\AES.a; ..\..\..\..\..\..\firmware\n32h49x_algo_lib\gcc\lib\Common.a; ..\..\..\..\..\..\firmware\n32h49x_algo_lib\gcc\lib\DES.a; ..\..\..\..\..\..\firmware\n32h49x_algo_lib\gcc\lib\HASH.a; ..\..\..\..\..\..\firmware\n32h49x_algo_lib\gcc\lib\RNG.a; ..\..\..\..\..\..\firmware\n32h49x_algo_lib\gcc\lib\SM4.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: delay.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32h49x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32h49x_std_periph_driver/src/: misc.c n32h49x_gpio.c n32h49x_rcc.c n32h49x_usart.c
  group LOG
    ../../../../bsp/src/: log.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32h49x_EWARM.s
  group USER
    ../src/: algo_demo.c main.c
